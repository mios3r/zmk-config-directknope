## config/boards/shields/directknope/Kconfig.defconfig
```kconfig
if SHIELD_DIRECTKNOPE

config ZMK_KEYBOARD_NAME
    default "directknope"

endif
```
